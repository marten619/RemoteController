# Keil uVision project A9112F4.uvproj, settings and files
target Target 1 (MCS-51)
  device: A9112 AMICCOM
  cpu: IRAM(0 - 0xFF) CLOCK(12800000)
  output: A9112F4 +hex
  c flags: SizeSpeed=1
  link misc: DW(16)
  group Source Group 1
    ../MCU/: STARTUP_AMC1.A51
    ../source/: main.c MasterI2C.c SHA_I2C.c
  group MCU
    ../MCU/: Uti.c MCU.c I2C.h MCU.h define.h uti.h
  group RF
    ../RF/: A9112F4_Function.c A9112F4_Function.h A9112F4.h A9112F4_config.h
    ../RF/LIB/: A9112F4_FunctionLIB.LIB
